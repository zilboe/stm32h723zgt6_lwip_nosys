# Keil uVision project stm32h723.uvprojx, settings and files
target Debug (6210000::V6.21::ARMCLANG)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: stm32h723 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx,LWIP_NOASSERT
  c include: ..\application\inc;..\bsp;..\hal_driver\STM32H7xx_HAL_Driver\Inc;..\hal_driver\STM32H7xx_HAL_Driver\Inc\Legacy;..\hal_driver\CMSIS\Device\ST\STM32H7xx\Include;..\hal_driver\CMSIS\Core\Include;..\FreeRTOS\kernel\include;..\FreeRTOS\kernel\port\RVDS\ARM_CM7\r0p1;..\FreeRTOS\kernel;..\lwip\src\include\;..\lwip\src\include\netif;..\lwip\contrib\ports\freertos\include\;..\lwip\src\include;..\lwip\contrib\ports\freertos\include;..\lwip_app
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group application
    ../application/src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c stm32h7xx_hal_timebase_tim.c netInfoConfig.c
  group bsp
    ../BSP/: startup_stm32h723xx.s
    ../bsp/: system_stm32h7xx.c
  group hal
    ../hal_driver/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c
  group FreeRTOS/Kernel
    ../FreeRTOS/kernel/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Port
    ../FreeRTOS/kernel/port/MemMang/: heap_4.c
    ../FreeRTOS/kernel/port/RVDS/ARM_CM7/r0p1/: port.c
  group FreeRTOS/Inc
    ../FreeRTOS/kernel/: FreeRTOSConfig.h
  group Net
    ../lwip/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
    ../lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../lwip/src/apps/mqtt/: mqtt.c
    ../lwip/src/apps/lwiperf/: lwiperf.c
  group Net/Arch
    ../lwip_app/src/: ethernetif.c lan8742.c lwip.c
  group Net/Inc
    ../lwip_app/: lwipopts.h
